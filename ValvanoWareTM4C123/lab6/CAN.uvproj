# Keil uVision project CAN.uvproj, settings and files
target CAN (ARM-ADS)
  device: LM4F120H5QR Texas Instruments
  cpu: IRAM(0x20000000-0x20007FFF) IROM(0-0x3FFFF) CLOCK(8000000) CPUTYPE("Cortex-M4") FPU2
  output: CAN
  c flags: Optim=1 OneElfS=1 wLevel=2
  c define: rvmdk PART_LM4F120H5QR
  c misc: --c99
  c include: ..;..\..\..
  memory RVCT4: ROM 0x0 size 0x40000
  memory RVCT9: RAM 0x20000000 size 0x8000
  group Source
    ./: startup.s main.c PeriodMeasure.c ST7735.c UART.c FIFO.h os.c PLL.c osasm.s uart_interp.c lcd_cmdLine.c sensor_cmdLine.c Retarget.c can.c can0.c interrupt.c atan.c IR.c get_dev_angle.c
